# Keil uVision project Platform.uvprojx, settings and files
target MIMXRT1064-EVK (6180000::V6.18::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, CODEC_WM8960_ENABLE, SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  c include: .;.\Driver_Audio\include
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor_sdram.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group App
    ./: Platform.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group Driver
    ./Driver_Audio/: Audio_MIMXRT1064-EVK.c Audio_MIMXRT1064-EVK.h Config_Audio.h Config_WM8960.h
    ./Driver_Audio/include/: audio_drv.h
  group MCUXpresso
    ./: MIMXRT1064-EVK.mex
  group Documentation
    ./: README.md
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 1.1.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.1.0, CMSIS Driver:VIO:Board 1.0.0, Board Support:SDK Drivers:evkmimxrt1064 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.2.0, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:CMSIS:MIMXRT1064_system 1.0.0, Device:SDK Drivers:cache 2.0.4, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:codec 2.3.0, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.3.1, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.3, Device:SDK Drivers:enet 2.5.3, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:i2c 2.3.1, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.5.2, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.5.2, Device:SDK Drivers:nic301 2.0.0, Device:SDK Drivers:sai 2.3.4, Device:SDK Drivers:sai_edma 2.5.0, Device:SDK Drivers:sdhc 2.8.1, Device:SDK Drivers:wm8960 2.2.0, Device:SDK Drivers:wm8960_adapter 2.2.0, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
