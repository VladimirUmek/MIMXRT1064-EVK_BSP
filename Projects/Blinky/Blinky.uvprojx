# Keil uVision project Blinky.uvprojx, settings and files
target MIMXRT1064-EVK (6160000::V6.16::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group App
    ./: Blinky.c
  group Board
    ./: main.c main.h
  group MCUXpresso
    ./: MIMXRT1064-EVK.mex
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.0, CMSIS Driver:VIO:Board 1.0.0, Board Support:SDK Drivers:evkmimxrt1064 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:CMSIS:MIMXRT1064_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:common 2.3.1, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.5.2, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:nic301 2.0.0, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
